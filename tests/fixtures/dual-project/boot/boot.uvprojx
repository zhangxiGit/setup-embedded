# Keil uVision project boot.uvprojx, settings and files
target Bootloader ()
  output: boot +hex
  scatter file: .\boot.sct
