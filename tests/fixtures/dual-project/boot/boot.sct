LR_IROM1 0x08000000 0x00004000 { ER_IROM1 0x08000000 0x00004000 { .ANY (+RO) } }
