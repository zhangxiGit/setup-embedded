# Keil uVision project app.uvprojx, settings and files
target Application ()
  output: app +hex
  scatter file: .\app.sct
