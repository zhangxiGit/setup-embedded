LR_IROM1 0x08008000 0x00038000 { ER_IROM1 0x08008000 0x00038000 { .ANY (+RO) } }
