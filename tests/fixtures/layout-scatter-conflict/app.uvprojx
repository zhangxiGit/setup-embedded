# Keil uVision project app.uvprojx, settings and files
target Application ()
  output: app
  scatter file: .\app.sct
