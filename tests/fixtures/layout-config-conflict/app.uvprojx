# Keil uVision project app.uvprojx, settings and files
target MainFirmware ()
  output: app
  scatter file: .\app.sct
