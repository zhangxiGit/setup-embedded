# Keil uVision project invalid-scatter.uvprojx, settings and files
target Application malformed scatter ()
  output: malformed
  scatter file: .\malformed.sct
target Application missing scatter ()
  output: missing
  scatter file: .\missing.sct
