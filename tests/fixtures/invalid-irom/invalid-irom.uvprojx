# Keil uVision project invalid-irom.uvprojx, settings and files
target Bootloader without IROM ()
  output: missing
  scatter file: .\missing.sct
target Uppercase IROM prefix ()
  output: upper
  scatter file: .\upper.sct
target Application with malformed IROM ()
  output: malformed
  scatter file: .\malformed.sct
target Application with malformed IROM size ()
  output: app-bad-size
  scatter file: .\app-bad-size.sct
